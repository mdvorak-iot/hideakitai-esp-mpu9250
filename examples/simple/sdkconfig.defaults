## examples/simple/sdkconfig.defaults
```kconfig
# This is mandatory, otherwise magnetometer won't work correctly
CONFIG_FREERTOS_HZ=1000
```
